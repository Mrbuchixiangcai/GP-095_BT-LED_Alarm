# Keil uVision project GP-095_BT-LED_Alarm.uvproj, settings and files
target Target 1 (MCS-51)
  device: M8051EW Mentor Graphics Co.
  cpu: IRAM(0 - 0xFF) XRAM(0-0xFFFF) IROM(0-0xFFFF) CLOCK(12000000) MOD517DP
  output: GP-095_BT-LED_Alarm +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Device;.\App_User\Include
  group Application/Device
    ./: STARTUP.A51
    ./Device/: main.c
  group Application/User
    ./App_User/Source/: app_main.c Key_Mode.c LED_Mode.c BT_Mode.c LED_Drive.c
